# beagley-ai-specific ultima-data-mount.service — see the unit for why.
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
